Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-06-17T13:51:04
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 17 13:51:04 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{9F0C5711-53C5-4292-B633-6B9E0F262A0D}\ifc * Database version: 5507 * Database creation date: Thu Jun 17 13:51:02 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jun 17 13:51:03 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 17 13:51:03 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 36711200_OER_11228120_KWT7112iG_EDST-CLST, 11228120_OER_KWT7112iG_EDST-CLST:36711200_OER_11228120_KWT7112iG_EDST-CLST:205678
In: Level 1
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Design_Glass, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Design_Steel_Chrom, z_Miele_Connection_Electric, Spruce, Polypropylene
Pset_BuildingElementProxyCommon - Reference: 36711200_OER_11228120_KWT7112iG_EDST-CLST
Pset_ManufacturerTypeInformation - Manufacturer: Miele
